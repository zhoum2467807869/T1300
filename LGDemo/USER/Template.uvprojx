# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\spi;..\..\LanGeI2cLib0.19;..\..\LanGeCalcLib0129;..\LANNGE_DISPLAY;..\LANNGE_ENCORE;..\LANNGE_HARDWARE;..\LANNGE_HARDWARE\24CXX;..\LANNGE_HARDWARE\IIC;..\GUI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c
  group HARDWARE
    ../LANNGE_HARDWARE/: Dis_API.c Font.c FSMC.c rtc.c key.c Channel.c touch.c 24cxx.c myiic.c
  group GUI
    ../GUI/: HomeActivity.c Component.c DelayActivity.c SwitchActivity.c TimerActivity.c Activity.c TimeActivity.c PWDActivity.c IPActivity.c AUZActivity.c UVOVActivity.c README_GUI.c PageSpinnerActivity.c
